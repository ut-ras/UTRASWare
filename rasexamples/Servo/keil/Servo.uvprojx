# Keil uVision project Servo.uvprojx, settings and files
target Servo (6150000::V6.15::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Servo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..\..\UTRASWare
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: ServoExample.c
    ../../../inc/: startup.s
    ../../../lib/Timer/: Timer.c
    ../../../lib/PWM/: PWM.c
    ../../../lib/PLL/: PLL.c
    ../../../lib/FaultHandler/: FaultHandler.c
    ../../../raslib/Servo/: Servo.c
    ../../../lib/GPIO/: GPIO.c
    ../../../lib/UART/: UART.c
